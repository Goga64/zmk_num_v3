## config/west.yml
```yaml
manifest:
  projects:
    - name: zmk
      url: https://github.com/goga64/my-zmk.git
      revision: main
      import: app/west.yml
  self:
    path: config
```
